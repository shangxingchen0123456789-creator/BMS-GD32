# Keil uVision project GD32G553_CHG.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: GD32G553VE GigaDevice
  pack: GigaDevice.GD32G5x3_DFP.1.2.0
  cpu: IRAM(0x20000000,0x18000) IRAM2(0x10000000,0x8000) IROM(0x08000000,0x07C000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: GD32G553_CHG
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32G553,USE_STDPERIPH_DRIVER
  c include: ..\Library;..\Library\Include;..\App;..\BSP;..\Common;..\Config;..\Driver;..\Module;..\Service;..\User;..\Utilities;..\FreeRTOS;..\FreeRTOS\portable;..\FreeRTOS\include
  memory RVCT4: ROM 0x8000000 size 0x7c000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group User
    ../User/: gd32g5x3_it.c main.c systick.c
    ../FreeRTOS/: FreeRTOSConfig.h
    ../Library/: startup_gd32g5x3.s
  group Library
    ../Library/Source/: gd32g5x3_adc.c gd32g5x3_can.c gd32g5x3_cau.c gd32g5x3_cau_aes.c gd32g5x3_cau_des.c gd32g5x3_cau_tdes.c gd32g5x3_cla.c gd32g5x3_cmp.c gd32g5x3_cpdm.c gd32g5x3_crc.c gd32g5x3_dac.c gd32g5x3_dbg.c gd32g5x3_dma.c gd32g5x3_exmc.c gd32g5x3_exti.c gd32g5x3_fac.c gd32g5x3_fft.c gd32g5x3_fmc.c gd32g5x3_fmc_ramfunc.c gd32g5x3_fwdgt.c gd32g5x3_gpio.c gd32g5x3_hpdf.c gd32g5x3_hrtimer.c gd32g5x3_i2c.c gd32g5x3_lptimer.c gd32g5x3_misc.c gd32g5x3_pmu.c gd32g5x3_rcu.c gd32g5x3_rtc.c gd32g5x3_syscfg.c gd32g5x3_timer.c gd32g5x3_tmu.c gd32g5x3_trigsel.c gd32g5x3_trng.c gd32g5x3_usart.c gd32g5x3_vref.c gd32g5x3_wwdgt.c
    ../Library/: system_gd32g5x3.c
  group App
    ../App/: app_tasks.c app_tasks.h
  group BSP
    ../BSP/: board_support.c board_support.h bms_uart.c bms_uart.h
  group Common
    ../Common/: bms_types.h pi_controller.c pi_controller.h battery_model.c battery_model.h
  group Config
    ../Config/: bms_board_config.h
  group Driver
    ../Driver/: adc_manager.c adc_manager.h afe_gd30bm2016.c afe_gd30bm2016_transport.c afe_gd30bm2016.h afe_gd30bm2016_transport.h afe_gd30bm2016_regs.h flash_storage.c flash_storage.h power_control.c power_control.h power_control_internal.h power_control_api.c power_control_safety.c power_control_limits.c power_control_mode.c power_pwm.c power_pwm.h
  group Module
    ../Module/: balance_manager.c balance_manager.h charge_manager.c charge_manager.h charge_manager_internal.h charge_manager_params.c charge_manager_path.c charge_manager_faults.c charge_manager_control.c charge_manager_commands.c power_manager.c power_manager.h power_path_manager.c power_path_manager.h soc_estimator.c soc_estimator.h
  group Service
    ../Service/: bms_comm_service.c bms_comm_service.h bms_protocol.c bms_protocol.h bms_state.c bms_state.h fault_log.c fault_log.h param_storage.c param_storage.h safety_manager.c safety_manager.h
  group FreeRTOS
    ../FreeRTOS/: tasks.c list.c queue.c timers.c event_groups.c stream_buffer.c
    ../FreeRTOS/portable/: heap_4.c port.c portasm.c
